# Keil uVision project TK18_Sample.uvproj, settings and files
target TK18_LIB_Sample (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: TK18code +hex
  c flags: Optimize=1
  c include: ..\src\main; ..\src\lib; ..\src\customer;
  group main
    ../src/main/: common.h main.c TK18_LIB_HW.c TK18_LIB_HW.h TK18_LIB_REG.h TK_MCU_DEF.h TK_SCAN_CFG.h
  group lib
    ../src/lib/: TK18_LIB_API.h TK18_LIB_API.LIB
  group customer
    ../src/customer/: ctm_sample.c ctm_sample.h TK_PWM.c TK_I2C_Master.c TK_GPIO.c
